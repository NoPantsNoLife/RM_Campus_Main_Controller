# Keil uVision project h750_motor_pid_pwm_ads7953.uvprojx, settings and files
target h750_motor_pid_pwm_ads7953 (6160000::V6.16::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h750_motor_pid_pwm_ads7953 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,STM32H743xx
  c include: ../Core/Inc;                  ../Drivers/STM32H7xx_HAL_Driver/Inc;                  ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                  ../Drivers/CMSIS/Include;                  ..\Drivers\SX1231;                  ..\Drivers\ADS7953;                  ..\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/: delay.c motor.c pid.c seek_line.c servo.c SX1231_APP.c
    ../Core/Src/: main.c gpio.c spi.c tim.c usart.c stm32h7xx_it.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_ll_spi.c stm32h7xx_ll_dma.c stm32h7xx_ll_bdma.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group drivers
    ../Drivers/ADS7953/: ADS7953.c
    ../Drivers/SX1231/: SX1231_Driver.c
software components: CMSIS:CORE 5.4.0
